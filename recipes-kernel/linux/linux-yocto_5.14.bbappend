FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "\
    file://0001-Inject-bug-to-crash-uptime.patch \
    file://debug-support.cfg \
    "
